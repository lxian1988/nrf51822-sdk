# Keil uVision project MDK.uvproj, settings and files
target nrf51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MDK +hex
  c flags: Optim=4 oTime=1
  c misc: --c99
  c include: ..\CODE\APP;..\CODE\CortexM0;..\CODE\Debug;..\CODE\nrf51822\inc;..\CODE\SoftDevice;..\CODE\SoftDevice\s110;..\CODE\Hardware;..\CODE\LX_NRF51Kit
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group APP
    ../CODE/APP/: app.c app_button.c app_timer.c main.c
  group CortexM0
    ../CODE/CortexM0/: arm_startup_nrf51.s
  group nrf51822
    ../CODE/nrf51822/src/: nrf51_delay.c nrf51_gpio.c nrf51_gpiote.c nrf51_timer.c nrf51_uart.c nrf51_uart_simulate.c system_nrf51.c nrf51_spi.c nrf51_radio.c nrf51_i2c.c nrf51_adc.c
  group SoftDevice
    ../CODE/SoftDevice/: softdevice_manager.c
  group Debug
    ../CODE/Debug/: debug.c
  group Hardware
    ../CODE/Hardware/: MX25L4006E.c
  group LX_NRF51Kit
    ../CODE/LX_NRF51Kit/lx_queue/: lx_queue.c
    ../CODE/LX_NRF51Kit/lx_fifo/: lx_fifo.c
    ../CODE/LX_NRF51Kit/lx_heap/: lx_heap.c
    ../CODE/LX_NRF51Kit/lx_notificationcenter/: lx_notificationcenter.c
    ../CODE/LX_NRF51Kit/lx_date/: lx_date.c
